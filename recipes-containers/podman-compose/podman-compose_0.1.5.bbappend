SRC_URI = "git://github.com/containers/podman-compose.git;branch=stable"
