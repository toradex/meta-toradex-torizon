PREFERRED_VERSION_${PYTHON_PN}-idna = "2.5"
