FILES_libvulkan-imx += "${libdir}/libvulkan_VSI${SOLIBS}"
FILES_libvulkan-imx-dev += "${libdir}/libvulkan_VSI${SOLIBSDEV}"
