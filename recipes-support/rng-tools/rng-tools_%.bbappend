PACKAGECONFIG_remove = "libjitterentropy"
PACKAGECONFIG_libc-musl_remove= "libjitterentropy"
