
SRC_URI = "git://github.com/commontorizon/tdx-info;protocol=https;branch=kirkstone"
SRCREV = "74704032f3ab1460c12ed1a4a3810dbc14eb0e73"
