SRC_URI_remove = "ftp://sources.redhat.com/pub/lvm2/LVM2.${PV}.tgz"
SRC_URI_prepend = "ftp://sources.redhat.com/pub/lvm2/old/LVM2.${PV}.tgz "
