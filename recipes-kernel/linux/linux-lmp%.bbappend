
FILESEXTRAPATHS:prepend := "${THISDIR}/linux-lmp-dev:"

SRC_URI:append = " \
    file://fragment.cfg \
"
