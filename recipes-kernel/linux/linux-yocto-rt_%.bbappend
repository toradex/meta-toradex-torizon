require linux-torizon.inc

inherit toradex-kernel-localversion
