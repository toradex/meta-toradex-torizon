SRCREV = "f4dc283124a9e456ec4cc4838c853709f9efdf99"
SRCBRANCH = "toradex_imx_4.14.78_1.0.0_ga-bring_up"
