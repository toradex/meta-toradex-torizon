RDEPENDS:${PN}:remove = "\
    connman-tools \
    connman-tests \
    connman-client \
    "
