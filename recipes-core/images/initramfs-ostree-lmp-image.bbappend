IMAGE_FSTYPES_remove += "teziimg"
