OS_RELEASE_FIELDS += "BUILD_ID ANSI_COLOR"

BUILD_ID = "${TDX_BUILDNBR}"
ANSI_COLOR = "1;34"
