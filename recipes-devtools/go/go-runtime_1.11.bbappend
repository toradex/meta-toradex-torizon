require go-1.11-fixes.inc
