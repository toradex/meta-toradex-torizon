require go-fixes.inc
