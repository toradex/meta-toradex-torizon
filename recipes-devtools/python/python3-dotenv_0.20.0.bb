HOMEPAGE = "https://github.com/pedroburon/dotenv"
SUMMARY = "Python Dot Env Handler"
DESCRIPTION = "Shell Command and Library to write and read .env like files."
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=55ee2c3471d386636a719c8ccac40b31"

PYPI_PACKAGE = "python-dotenv"

SRC_URI[md5sum] = "f7ebce154a659291692d3f8ccf0dc095"
SRC_URI[sha256sum] = "b7e3b04a59693c42c36f9ab1cc2acc46fa5df8c78e178fc33a8d4cd05c8d498f"

inherit pypi setuptools3
