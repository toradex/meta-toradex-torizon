FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI:append = " file://0001-ScriptWriter-create-more-efficient-usr-bin-wrappers-signoff-included.patch"
