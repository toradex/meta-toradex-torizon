require torizon-minimal.bb
require torizon-core-dev.inc
DESCRIPTION = "Torizon OS Reference Minimal Image, featuring secure OTA update \
capabilities (with debugging tools)."
