require torizon-core-podman.bb
require torizon-core-dev.inc
DESCRIPTION = "TorizonCore Linux experimental image based on production image \
using Podman container engine (with debugging tools)."
