require torizon-core-lite.bb
require torizon-core-dev.inc
DESCRIPTION = "Minimal TorizonCore console image, featuring secure OTA update \
capabilities (with debugging tools)."
