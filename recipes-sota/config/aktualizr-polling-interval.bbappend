SOTA_POLLING_SEC = "300"
