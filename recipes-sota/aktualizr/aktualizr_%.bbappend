do_fetch[lockfiles] += "${DL_DIR}/aktualizr.lock"
